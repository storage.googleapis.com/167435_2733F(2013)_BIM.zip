Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-14T08:26:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.2.0.0 - Alternate UI 16.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 14 08:26:17 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{5D9248F2-E024-41F0-AF98-3889B3DBB287}\ifc * Database version: 5507 * Database creation date: Thu Jun 14 08:26:17 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 14 08:26:17 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 14 08:26:17 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcFlowController: 2733F Kitchen faucet, 2733F(2013):2733F Kitchen faucet:298034
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 282.5 mm; NominalHeight: 328 mm; NominalWidth: 54 mm
Type - General - Author: Convergo AB; BIMObjectName: 2733F(2013); ConvergoRefNr: 0087-1806-0037-FI; ExpiringDate: 12/2018; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Kitchen faucet with an easy-grip lever, high swivel spout and aerator.; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 07/06/2018
Type - Green Building Properties - EAN Number: 6414150070013; EN Standard: EN 817; ETA-Danmark: VA 1.42/20421; LVI Number: 6219071; Noise Class: I (ISO 3822); NRF Number: 4200378; RSK Number: 8553481; Sintef Certificate: Sintef Nr. 3084; STF Certificate: VTT-RTH-00007-14; VVS Number: 705887504
Type - Identity Data - Class: Single lever; Group: Kitchen faucets; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;NOR;POL;RUS;SWE;UKR; Model: 2733F Kitchen faucet; Name_en: 2733F Kitchen faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2733F; Product Datasheet: https://www.oras.com/datasheet/2733F/en; Product Family: Oras Optima; Product URL: https://www.oras.com/en/products/oras-optima/product/2733F/; Type Name: 2733F Kitchen faucet; Usage Group: Hospitals, schools, households
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Aerator: Aerator; Flow Rate At 300kPa: 0.00776923 m3/s; Installation Type: Deck mounted; Lever Handle: Easy grip lever; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 1 mounting hole; Pipes: Flexible inlet pipes; Pressure Loss With Flow 02ls: 250000 Pa; Spout Type: Swivel spout
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2733F(2013); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2733F; Name: 2733F Kitchen faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 54x283x328 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2733F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2733F Kitchen faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 0; Level: Level: Level 0; Offset: 0 mm
Dimensions - Area: 0.126727 m2; Volume: 0.00500835 m3
Identity Data - Mark: 3
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2733F(2013): 2733F Kitchen faucet; Family and Type: 2733F(2013): 2733F Kitchen faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2733F(2013): 2733F Kitchen faucet; Type Id: 2733F(2013): 2733F Kitchen faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
